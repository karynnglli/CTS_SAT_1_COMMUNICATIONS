options:
  parameters:
    author: Karynn Martin-Li (karynn.li@ucalgary.ca)
    description: demodulator and decoder application for CTS SAT-1 mission
    generate_options: qt_gui
    id: demod_decode_for_downlink
    output_language: python
    title: demodulator/decoder
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: '4800'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '436150000'
  states: {}
- name: gain_mu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: firdes.gaussian (1.5, 2* (samp_rate / baud_rate) , 0.5, 12)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_message_debug_2_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0_3
  id: blocks_tag_debug
  parameters:
    name: FSKDemod
    type: float
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    name: HackerRFSource
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_1_0
  id: blocks_tag_debug
  parameters:
    name: LPF
    type: complex
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '100'
    gain: '1'
    samp_rate: 10e6
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: GMSK9k6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth/2
    fc: '0'
    fftsize: '1024'
    name: '"LPF"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: bandwidth/2
    fc: '0'
    fftsize: '1024'
    name: '"FSKDemod"'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '12'
    type: ccc
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: '4'
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    comment: |-
      Failed Polynomials:
      0x1CF5 = found in AX 100 Deframer (1 of 2)
      0x11021 = from ChatGPT
    final_xor: '0x1000'
    initial_value: '0x1FFF'
    input_reflected: 'False'
    poly: '0x1CF5'
    result_reflected: 'False'
    swap_endianness: 'True'
  states: {state: disabled}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    samp_rate: samp_rate
    subaudio: 'True'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    samp_rate: 10e6
    type: fc32
  states: {}

connections:
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_tag_debug_1_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax100_deframer_0, out, blocks_message_debug_2_0, print]
- [satellites_ax100_deframer_0, out, satellites_crc_check_0, in]
- [satellites_crc_check_0, fail, blocks_message_debug_2_0, print]
- [satellites_crc_check_0, ok, blocks_message_debug_2_0, print]
- [satellites_fsk_demodulator_0, '0', blocks_tag_debug_0_3, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_sink_x_0_0, '0']
- [satellites_fsk_demodulator_0, '0', satellites_ax100_deframer_0, '0']
- [soapy_hackrf_source_0, '0', blocks_correctiq_0, '0']
- [soapy_hackrf_source_0, '0', blocks_tag_debug_1, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
